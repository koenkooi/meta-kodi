PACKAGECONFIG:append:class-target = " gnutls nghttp2 rtmpdump rtsp"

