# needed to build shairplay
PACKAGECONFIG:append = " libdns_sd"

