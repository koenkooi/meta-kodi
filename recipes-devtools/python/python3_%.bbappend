FILESEXTRAPATHS:prepend := "${THISDIR}/python3:"

SRC_URI:append = "file://0001-Revert-bpo-44050-Extension-modules-can-share-state-w.patch"

