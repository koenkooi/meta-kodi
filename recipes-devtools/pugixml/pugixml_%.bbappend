inherit native

EXTRA_OECMAKE += "-DBUILD_PKGCONFIG=ON"
BBCLASSEXTEND = "native nativesdk"
