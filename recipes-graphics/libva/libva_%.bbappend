DEPENDS:remove = "virtual/mesa"
PACKAGECONFIG:remove = "glx"
